# Keil uVision project sample.uvprojx, settings and files
target LandTiger_LPC1768 (release) (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TETRIS
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: .\Source;.\Source\button_EXINT;.\Source\CMSIS_core;.\Source\led;.\Source\RIT
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./Source/: startup_LPC17xx.s
  group main
    ./Source/: tetris.c sample.c tetris.h
  group lib_SoC_board
    ./Source/: system_LPC17xx.c
  group led
    ./Source/led/: funct_led.c lib_led.c led.h
  group button_EINT
    ./Source/button_EXINT/: button.h IRQ_button.c lib_button.c
  group RIT
    ./Source/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group GLCD
    ./Source/GLCD/: AsciiLib.c GLCD.c HzLib.c AsciiLib.h GLCD.h HzLib.h
  group joystick
    ./Source/joystick/: funct_joystick.c lib_joystick.c joystick.h
  group TouchPanel
    ./Source/TouchPanel/: TouchPanel.h TouchPanel.c
  group timer
    ./Source/timer/: IRQ_timer.c lib_timer.c timer.h
  group adc
    ./Source/adc/: adc.h IRQ_adc.c lib_adc.c
target SW_Debug (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: as above
  output: TETRIS
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: SIMULATOR
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 6.1.0
